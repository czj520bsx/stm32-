# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM;..\HADEWARE\ADC;..\HADEWARE\LED;..\HADEWARE\OLED;..\HADEWARE\TIMER;..\HADEWARE\BEEP;..\NET_DEVICE;..\OneNet;..\MQTT;..\CJSON;..\HADEWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HADEWARE
    ../HADEWARE/TIMER/: timer.c
    ../HADEWARE/ADC/: MQ4_adc.c JW.c
    ../HADEWARE/LED/: led.c
    ../HADEWARE/OLED/: oled.c
    ../HADEWARE/BEEP/: beep.c
  group NET_HADE
    ../NET_DEVICE/: esp8266.c
  group NET_ONENET
    ../OneNet/: base64.c hmac_sha1.c onenet.c
  group NET_PROTOCAL
    ../MQTT/: MqttKit.c
  group CJSON
    ../CJSON/: cJSON.c
